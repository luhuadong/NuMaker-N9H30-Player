# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c misc: --c99
  c include: applications;.;board;rt-thread/components/libc/compilers/common/include;rt-thread/components/libc/compilers/common/extension;rt-thread/components/libc/compilers/common/extension/fcntl/octal;rt-thread/libcpu/arm/common;rt-thread/libcpu/arm/arm926;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/spi;rt-thread/components/drivers/include;rt-thread/components/drivers/spi/sfud/inc;rt-thread/components/drivers/include;rt-thread/components/drivers/audio;rt-thread/components/drivers/include;rt-thread/components/drivers/touch;rt-thread/components/drivers/include;libraries/n9h30/rtt_port;rt-thread/components/fal/inc;rt-thread/components/dfs/include;rt-thread/components/dfs/filesystems/devfs;rt-thread/components/dfs/filesystems/elmfat;rt-thread/components/finsh;.;rt-thread/include;libraries/n9h30/Driver/Include;applications/lvgl;rt-thread/components/net/lwip/lwip-2.0.3/src/include;rt-thread/components/net/lwip/lwip-2.0.3/src/include/ipv4;rt-thread/components/net/lwip/lwip-2.0.3/src/include/netif;rt-thread/components/net/lwip/port;libraries/n9h30/UsbHostLib/inc;libraries/nu_packages/ADC_TOUCH;libraries/nu_packages/AudioCodec;libraries/nu_packages/TPC;libraries/nu_packages/NuUtils/inc;rt-thread/components/libc/posix/io/poll;rt-thread/components/libc/posix/io/stdio;rt-thread/components/libc/posix/ipc;rt-thread/components/drivers/usb/usbdevice;rt-thread/components/drivers/usb/usbhost;rt-thread/components/drivers/usb/usbhost/class;rt-thread/components/drivers/usb/usbhost/core;rt-thread/components/drivers/usb/usbhost/include;rt-thread/components/drivers/include;rt-thread/components/net/netdev/include;rt-thread/components/net/sal/include;rt-thread/components/net/sal/include/socket;rt-thread/components/net/sal/impl;rt-thread/components/net/sal/include/dfs_net;rt-thread/components/net/sal/include/socket/sys_socket;rt-thread/components/utilities/utest
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\n9h30.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c rt_drv_pwm.c rt_inputcapture.c
    rt-thread/components/drivers/rtc/: alarm.c rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/touch/: touch.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    libraries/n9h30/rtt_port/: drv_ge2d.c drv_gpio.c drv_i2s.c drv_crypto.c drv_jpegcodec.c drv_timer.c drv_qspi.c drv_i2c.c drv_sdh.c drv_common.c drv_pwm.c drv_systick.c drv_usbd.c drv_rtc.c drv_emac.c drv_etimer.c drv_wdt.c drv_softi2c.c drv_etimer_capture.c drv_vpost.c drv_sys.c drv_uart.c drv_can.c drv_scuart.c drv_adc.c drv_usbhost.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal_rtt.c fal_partition.c fal.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c msh_file.c msh_parse.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    libraries/n9h30/Driver/Source/: nu_can.c nu_uart.c nu_sys.c nu_etimer.c nu_sdh.c nu_scuart.c nu_fmi.c nu_crypto.c nu_i2s.c nu_wwdt.c nu_cap.c nu_gpio.c nu_pwm.c nu_wdt.c nu_usbd.c nu_timer.c nu_lcd.c nu_emac.c nu_rtc.c nu_spi.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_port_indev.c lv_port_disp.c lv_gpu_n9h30_ge2d.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group n9h30_usbhostlib
    libraries/n9h30/UsbHostLib/src/: ehci.c usb_core.c support.c mem_alloc.c ehci_iso.c ohci.c
  group nu_pkgs_adc_touch
    libraries/nu_packages/ADC_TOUCH/: touch_sw.c adc_touch.c
  group nu_pkgs_nau8822
    libraries/nu_packages/AudioCodec/: acodec_nau8822.c audio_test.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
    rt-thread/components/drivers/usb/usbdevice/class/: mstorage.c cdc_vcom.c
  group rt_usbh
    rt-thread/components/drivers/usb/usbhost/core/: hub.c driver.c usbhost_core.c usbhost.c
    rt-thread/components/drivers/usb/usbhost/class/: udisk.c mass.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
